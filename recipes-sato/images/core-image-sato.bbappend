IMAGE_INSTALL_append = " pitft-init-sato"
